Commit message: Finish 1st version of two-robot game

File: urdf/seveneffort2_clone.urdf (robot description, URDF)
Before this commit: robot sevenbot2, 30 links, 29 joints
Joints:
- joint theta1: origin xyz=0 0 0.6 rpy=0 0 0 -> xyz=1 0 0.6 rpy=0 0 0
