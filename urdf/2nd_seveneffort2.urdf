Commit message: fixed issues and changed coordinates

File: urdf/2nd_seveneffort2.urdf (robot description, URDF)
Before this commit: robot sevenbot2, 30 links, 29 joints
Joints:
- joint theta1: origin xyz=0 0 0.6 rpy=0 0 0 -> xyz=4 0 0.6 rpy=0 0 0
