Commit message: initial commit

File: urdf/seveneffort2_r4.urdf (robot description, URDF)
Before this commit: robot sevenbot2, 30 links, 29 joints
Joints:
- joint theta1: origin xyz=1 0 0.6 rpy=0 0 0 -> xyz=2 0 0.6 rpy=0 0 0
